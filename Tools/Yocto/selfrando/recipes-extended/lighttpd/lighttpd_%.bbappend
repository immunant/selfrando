
inherit selfrandomize

